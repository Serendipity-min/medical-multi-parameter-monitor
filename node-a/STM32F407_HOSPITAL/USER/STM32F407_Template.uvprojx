# Keil uVision project STM32F407_Template.uvprojx, settings and files
target STM32F407_Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\HARDWARE;..\HARDWARE\SYS;..\HARDWARE\DEBUG;..\HARDWARE\USART;..\HARDWARE\HMI;..\HARDWARE\UNO;..\HARDWARE\CANopen
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HARDWARE
    ../HARDWARE/SYS/: sys.c sys_wdt.c screen_watch.c node_status.c
    ../HARDWARE/DEBUG/: debug.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/HMI/: dc_hmi.c app_bloodoxygen.c hmi_ids.h
    ../HARDWARE/UNO/: uno.c
    ../HARDWARE/: app_bp.c hmi_dacai.c bp_sensor.c
  group CANopen
    ../HARDWARE/CANopen/: canopen_app.c CO_driver.c OD.c CANopen.c
    ../HARDWARE/CANopen/301/: CO_ODinterface.c CO_NMT_Heartbeat.c CO_HBconsumer.c CO_Emergency.c CO_fifo.c CO_SDOserver.c CO_TIME.c CO_SYNC.c CO_PDO.c
    ../HARDWARE/CANopen/303/: CO_LEDs.c
    ../HARDWARE/CANopen/305/: CO_LSSslave.c
