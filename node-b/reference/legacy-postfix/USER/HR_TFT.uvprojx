# Keil uVision project HR_TFT.uvprojx, settings and files
target HR_TFT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: HR_TFT +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\HARDWARE;..\SCREEN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group HARDWARE
    ../HARDWARE/: spi.c ads1292.c ecg_filter.c pan_tompkins.c resp_rate.c timer.c systick.c beep.c hr_page.c can.c canopen.c
    ../CORE/: arm_cortexM4lf_math.lib
  group SCREEN
    ../SCREEN/: cmd_queue.c cmd_process.c hmi_driver.c hmi_user_uart.c hw_config.c ulitity.c
  group AcquisitionQueue
    ../HARDWARE/: ecg_frame_queue.c
