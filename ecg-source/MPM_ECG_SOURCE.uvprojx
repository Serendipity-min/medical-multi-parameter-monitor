# Keil uVision project MPM_ECG_SOURCE.uvprojx, settings and files
target MPM_ECG_SOURCE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(8000000) ELITTLE
  output: MPM_ECG_SOURCE
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,__FPU_PRESENT=1
  c include: .\src;.\platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Dedicated_source_only
    ./src/: main.c source_driver.c source_waveform.c waveform_tables.c
    ./platform/: system_stm32f4xx.c startup_stm32f40_41xxx.s
